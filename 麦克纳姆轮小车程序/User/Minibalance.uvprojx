# Keil uVision project Minibalance.uvprojx, settings and files
target Minibalance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\MiniBalance_COER;..\STM32F10x_FWLib\inc;..\MiniBalance_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MiniBalance_HARDWARE\DMP;..\MiniBalance_HARDWARE\IIC;..\MiniBalance_HARDWARE\MPU6050;..\MiniBalance_HARDWARE\ENCODER;..\MiniBalance_HARDWARE\OLED;..\MiniBalance\show;..\MiniBalance_HARDWARE\LED;..\MiniBalance_HARDWARE\KEY;..\MiniBalance_HARDWARE\ADC;..\MiniBalance_HARDWARE\MOTOR;..\MiniBalance_HARDWARE\EXTI;..\MiniBalance\DataScope_DP;..\MiniBalance\filter;..\MiniBalance_HARDWARE\STMFLASH;..\MiniBalance_HARDWARE\USARTX;..\MiniBalance_HARDWARE\CAN;..\MiniBalance_HARDWARE\PS2;..\MiniBalance_HARDWARE\TIMER;..\MiniBalance_HARDWARE\DMA;..\MiniBalance_COER;..\MiniBalance_HARDWARE\LINE;..\MiniBalance\CONTROL;..\MiniBalance_HARDWARE\imageprocess
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../MiniBalance_COER/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../MiniBalance_HARDWARE/LED/: LED.C
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/OLED/: oled.c
    ../MiniBalance_HARDWARE/ADC/: adc.c
    ../MiniBalance_HARDWARE/MOTOR/: motor.c
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/IIC/: IOI2C.c
    ../MiniBalance_HARDWARE/EXTI/: exti.c
    ../MiniBalance_HARDWARE/USARTX/: usartx.c
    ../MiniBalance_HARDWARE/PS2/: pstwo.c
    ../MiniBalance_HARDWARE/DMA/: dma.c
    ../MiniBalance_HARDWARE/LINE/: Line.c
    ../MiniBalance_HARDWARE/imageprocess/: imageprocess.c
  group Minibalance
    ../MiniBalance/CONTROL/: control.c
    ../MiniBalance/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MiniBalance/filter/: filter.c
    ../MiniBalance/MPU6050/: MPU6050.c
    ../MiniBalance/show/: show.c
    ../MiniBalance/DataScope_DP/: DataScope_DP.C
